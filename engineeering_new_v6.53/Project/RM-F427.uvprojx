# Keil uVision project RM-F427.uvprojx, settings and files
target 底盘 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM_typeA +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx,
  c misc: --c99
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\User\Init;..\User\remote;..\User\remote_code;..\APP\angle_pid;..\APP\judge;..\APP\kinematic;..\APP\motor;..\APP\push;..\APP\speed_pid;..\APP\steering_engine;..\APP\TIM3_Events;..\BSP\algorithm;..\BSP\bsp_led;..\BSP\can;..\BSP\delay;..\BSP\flag;..\BSP\referee;..\BSP\sys;..\BSP\usart;..\Hardware\bsp_dbus;..\Hardware\CAN_receive;..\Hardware\DJi_remote;..\Hardware\key;..\Hardware\LED;..\Hardware\limit_switch;..\Hardware\power;..\Hardware\stepper_motor;..\Hardware\timer;..\BSP\encoder
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427_437xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash_md5.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_cryp.c stm32f4xx_hash.c stm32f4xx_exti.c
  group USER
    ../User/: main.c stm32f4xx_it.c
    ../User/Init/: My_Init.c
    ../User/remote_code/: remote_code.c
  group APP
    ../APP/kinematic/: kinematic.c
    ../APP/angle_pid/: angle_pid.c
    ../APP/speed_pid/: speed_pid.c
    ../APP/judge/: judge.c
    ../APP/TIM3_Events/: Tim3_Events.c
    ../APP/motor/: motor.c
    ../APP/push/: push.c
    ../APP/steering_engine/: steering_engine.c
  group BSP
    ../BSP/can/: can.c
    ../BSP/delay/: delay.c
    ../BSP/sys/: sys.c
    ../BSP/algorithm/: algorithm.c
    ../BSP/bsp_led/: bsp_led.c
    ../BSP/referee/: referee.c
    ../BSP/encoder/: encoder.c
  group HARDWARE
    ../BSP/usart/: uart5.c bsp_debug_usart.c
    ../Hardware/limit_switch/: limit_switch.c
    ../Hardware/power/: power.c
    ../Hardware/key/: key.c
    ../Hardware/LED/: LED.c
    ../Hardware/bsp_dbus/: bsp_dbus.c
    ../Hardware/timer/: timer.c
  group DOC
    ../Doc/: 说明.txt
software components: Data Exchange:JSON:Jansson 2.7.0
